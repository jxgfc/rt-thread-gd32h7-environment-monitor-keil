# Keil uVision project project.uvprojx, settings and files
target rtthread (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: GD32H759IM GigaDevice
  pack: GigaDevice.GD32H7xx_DFP.1.5.0
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, GD32H7XX, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, USE_STDPERIPH_DRIVER, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS
  c include: ..\..\..\..\include;packages\LVGL-v8.3.11\src\extra\libs\qrcode;packages\LVGL-v8.3.11\src\extra\others\snapshot;packages\LVGL-v8.3.11\src\hal;packages\LVGL-v8.3.11\src\extra\others;packages\LVGL-v8.3.11\src\misc;packages\LVGL-v8.3.11\src\extra\libs\bmp;packages\LVGL-v8.3.11\src\draw\sdl;packages\LVGL-v8.3.11\src\extra\libs\sjpg;packages\LVGL-v8.3.11\src\extra\libs\tiny_ttf;..\libraries\gd32_drivers;packages\LVGL-v8.3.11\src\extra\widgets\tileview;..\..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\draw\nxp\pxp;packages\LVGL-v8.3.11\src\extra\libs\gif;packages\LVGL-v8.3.11\src\font;packages\LVGL-v8.3.11\src\extra\widgets\msgbox;packages\LVGL-v8.3.11\src\extra\widgets\imgbtn;..\..\..\..\components\libc\posix\ipc;packages\LVGL-v8.3.11\src\draw\stm32_dma2d;packages\LVGL-v8.3.11\src\extra\others\imgfont;..\libraries\gd32_drivers\config;packages\LVGL-v8.3.11\src\extra\others\gridnav;..\..\..\..\components\dfs\dfs_v1\include;packages\LVGL-v8.3.11\src\extra\others\fragment;packages\LVGL-v8.3.11\src\extra\widgets\spinner;packages\LVGL-v8.3.11\src\draw\swm341_dma2d;packages\LVGL-v8.3.11\src\extra\widgets\keyboard;packages\LVGL-v8.3.11\src\draw;..\..\..\..\libcpu\arm\common;packages\LVGL-v8.3.11\src\extra\libs\freetype;packages\LVGL-v8.3.11\src\extra\widgets\meter;..\..\..\..\libcpu\arm\cortex-m7;packages\LVGL-v8.3.11\src\extra\widgets\calendar;packages\LVGL-v8.3.11\src\extra\libs;..\..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\core;packages\LVGL-v8.3.11\src\extra\widgets\span;..\..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\themes\default;packages\LVGL-v8.3.11\src\extra\layouts\flex;packages\LVGL-v8.3.11\src\extra\others\monkey;packages\LVGL-v8.3.11\src\extra\themes;packages\LVGL-v8.3.11\src\extra\widgets\chart;packages\LVGL-v8.3.11\src\extra;packages\LVGL-v8.3.11\src\draw\renesas;packages\LVGL-v8.3.11\env_support\rt-thread;packages\LVGL-v8.3.11\src\draw\nxp\vglite;..\..\..\..\components\finsh;packages\LVGL-v8.3.11\src\draw\arm2d;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\libc\compilers\common\extension;packages\gd32-arm-cmsis-latest\GD32H7xx;packages\LVGL-v8.3.11\src\extra\themes\basic;..\..\..\..\components\libc\posix\io\poll;packages\LVGL-v8.3.11\src\extra\libs\ffmpeg;..\..\..\..\components\libc\compilers\common\include;packages\LVGL-v8.3.11\src\extra\libs\png;..\..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\widgets\tabview;packages\gd32-arm-series-latest\GD32H7xx\GD32H7xx_standard_peripheral\Include;board;packages\LVGL-v8.3.11\src\extra\widgets\list;packages\LVGL-v8.3.11\src\extra\themes\mono;packages\LVGL-v8.3.11\src\extra\widgets;..\..\..\..\components\drivers\include;packages\LVGL-v8.3.11\src\extra\others\ime;applications;packages\LVGL-v8.3.11\src\draw\sw;..\..\..\..\components\net\utest;packages\LVGL-v8.3.11\src\extra\widgets\led;packages\LVGL-v8.3.11\src\widgets;packages\LVGL-v8.3.11\src\extra\layouts\grid;packages\LVGL-v8.3.11\src\extra\libs\fsdrv;..\..\..\..\components\drivers\include;.;packages\LVGL-v8.3.11\src;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\libc\posix\io\epoll;packages\LVGL-v8.3.11\src\extra\layouts;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;packages\gd32-arm-cmsis-latest\GD32H7xx\GD\GD32H7xx\Include;packages\LVGL-v8.3.11\src\extra\widgets\colorwheel;packages\LVGL-v8.3.11\src\extra\widgets\menu;packages\LVGL-v8.3.11\src\extra\libs\rlottie;packages\LVGL-v8.3.11\src\extra\widgets\animimg;packages\LVGL-v8.3.11\src\extra\others\msg;applications\lvgl;packages\LVGL-v8.3.11\src\extra\widgets\spinbox;packages\LVGL-v8.3.11\src\extra\widgets\win;..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c env_log.c alarm.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c drv_gt911.c drv_tli_lcd.c sensor_service.c drv_rtc.c drv_sdcard.c sdcard.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_hard_i2c.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/gd32-arm-series-latest/GD32H7xx/GD32H7xx_standard_peripheral/Source/: gd32h7xx_rtc.c gd32h7xx_sdio.c gd32h7xx_dma.c gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_i2c.c gd32h7xx_ipa.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_syscfg.c gd32h7xx_tli.c gd32h7xx_usart.c
    packages/gd32-arm-cmsis-latest/GD32H7xx/GD/GD32H7xx/Source/ARM/: startup_gd32h7xx.s
    packages/gd32-arm-cmsis-latest/GD32H7xx/GD/GD32H7xx/Source/: system_gd32h7xx.c
  group LVGL
    packages/LVGL-v8.3.11/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    packages/LVGL-v8.3.11/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    packages/LVGL-v8.3.11/src/extra/: lv_extra.c
    packages/LVGL-v8.3.11/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    packages/LVGL-v8.3.11/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.3.11/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    packages/LVGL-v8.3.11/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    packages/LVGL-v8.3.11/src/draw/arm2d/: lv_gpu_arm2d.c
    packages/LVGL-v8.3.11/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    packages/LVGL-v8.3.11/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    packages/LVGL-v8.3.11/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.3.11/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    packages/LVGL-v8.3.11/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    packages/LVGL-v8.3.11/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.3.11/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    packages/LVGL-v8.3.11/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.3.11/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.3.11/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.3.11/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.3.11/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.3.11/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    packages/LVGL-v8.3.11/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.3.11/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.3.11/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.3.11/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.3.11/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.3.11/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    packages/LVGL-v8.3.11/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    packages/LVGL-v8.3.11/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.3.11/src/extra/others/ime/: lv_ime_pinyin.c
    packages/LVGL-v8.3.11/src/extra/others/imgfont/: lv_imgfont.c
    packages/LVGL-v8.3.11/src/extra/others/monkey/: lv_monkey.c
    packages/LVGL-v8.3.11/src/extra/others/msg/: lv_msg.c
    packages/LVGL-v8.3.11/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.3.11/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.3.11/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.3.11/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.3.11/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.3.11/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    packages/LVGL-v8.3.11/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.3.11/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.3.11/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.3.11/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.3.11/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.3.11/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.3.11/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.3.11/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.3.11/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.3.11/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.3.11/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.3.11/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.3.11/src/extra/widgets/win/: lv_win.c
  group LVGL application
    applications/lvgl/: hmi_pages.c lv_port_disp.c lvgl_app.c ui_font_14.c ui_font_18.c
  group LVGL-port
    packages/LVGL-v8.3.11/env_support/rt-thread/: lv_rt_thread_port.c
